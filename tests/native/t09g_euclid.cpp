// Source fixtures: circuitpython-source/src/apps/Orion/modules/euclid.py with core/note_array.py,
// core/utils.py (grid_change) and adafruit_ticks (2**29 wrap). Traces live in
// fixtures/t09g_source_traces.inc and the euclid_step tables in the same file, generated by
// fixtures/t09g/gen_traces.py under python -I. Every trace step is compared in order.
#include "domain/modules/registry.hpp"
#include "domain/modules/euclid.hpp"
#include <cassert>
#include <cstddef>
#include <cstdint>
#include <cstdio>
#include <cstring>
#include <initializer_list>

namespace {
using namespace orbit;

struct Pair {
  std::uint8_t pitch;
  std::uint8_t velocity;
};

// Replays one module through its descriptor, the same way the chain calls it.
struct Run {
  explicit Run(const ModuleDescriptor& descriptor) : d(descriptor) { d.construct(state); }
  ~Run() { d.destroy(state); }
  Run(const Run&) = delete;
  Run& operator=(const Run&) = delete;

  void set_int(std::uint8_t index, std::int32_t value) {
    std::uint8_t effects = 0;
    assert(d.set_param(state, index, ParamValue::integer(value), global, effects));
  }
  void set_float(std::uint8_t index, float value) {
    std::uint8_t effects = 0;
    assert(d.set_param(state, index, ParamValue::decimal(value), global, effects));
  }
  void stop() { d.reset(state, ResetReason::Stop); }

  NoteBatch process(std::uint32_t now, std::uint32_t tick, bool running, std::initializer_list<Pair> on,
                    std::initializer_list<std::uint8_t> off) {
    NoteBatch input{}, output{};
    for (const auto& p : on) assert(input.on.append({p.pitch, p.velocity, 0}) == PushResult::Added);
    for (const auto p : off) assert(input.off.append({p, 0, 0}) == PushResult::Added);
    TransportView view{};
    view.running = running;
    view.tick = tick;
    ProcessContext context{TimeSample{now, 0}, global, view, random};
    d.process(state, context, input, output);
    assert(!output.overflowed());
    assert(output.on.count <= kProcessors * 2 && output.off.count <= kProcessors * 2);
    return output;
  }

  void step(std::uint32_t now, std::uint32_t tick, bool running, std::initializer_list<Pair> on,
            std::initializer_list<std::uint8_t> off, std::initializer_list<Pair> expected_on,
            std::initializer_list<std::uint8_t> expected_off) {
    const auto output = process(now, tick, running, on, off);
    if (!matches(output, expected_on, expected_off)) {
      std::fprintf(stderr, "MISMATCH now=%u tick=%u running=%d out_on=%u out_off=%u\n", now, tick, running ? 1 : 0,
                   static_cast<unsigned>(output.on.count), static_cast<unsigned>(output.off.count));
      for (std::uint16_t i = 0; i < output.on.count; ++i) std::fprintf(stderr, " on %u/%u", output.on.items[i].pitch, output.on.items[i].velocity);
      for (std::uint16_t i = 0; i < output.off.count; ++i) std::fprintf(stderr, " off %u", output.off.items[i].pitch);
      std::fprintf(stderr, "\n");
    }
    assert(matches(output, expected_on, expected_off));
  }

  static bool matches(const NoteBatch& output, std::initializer_list<Pair> on, std::initializer_list<std::uint8_t> off) {
    if (static_cast<std::size_t>(output.on.count) != on.size()) return false;
    if (static_cast<std::size_t>(output.off.count) != off.size()) return false;
    std::size_t i = 0;
    for (const auto& p : on) {
      if (output.on.items[i].pitch != p.pitch || output.on.items[i].velocity != p.velocity) return false;
      ++i;
    }
    i = 0;
    for (const auto p : off) {
      if (output.off.items[i++].pitch != p) return false;
    }
    return true;
  }

  const ModuleDescriptor& d;
  ModuleState state{};
  GlobalState global{};
  RandomSource random{};
};

#include "fixtures/t09g_source_traces.inc"

// Attribute visitor helper: records names, element counts and value addresses in visit order.
struct Collect {
  std::uint8_t count = 0;
  const char* names[4]{};
  std::uint16_t elements[4]{};
  AttributeType types[4]{};
  void* values[4]{};
};

bool collect(void* ctx, AttributeDescriptor& attr) {
  auto* c = static_cast<Collect*>(ctx);
  c->names[c->count] = attr.name;
  c->elements[c->count] = attr.element_count;
  c->types[c->count] = attr.type;
  c->values[c->count] = attr.values;
  ++c->count;
  return true;
}

// Simulates a scene restore that writes a zero length into lane 0.
bool zero_length_lane0(void* ctx, AttributeDescriptor& attr) {
  (void)ctx;
  if (std::strcmp(attr.name, "lengths") == 0) static_cast<std::uint8_t*>(attr.values)[0] = 0;
  return true;
}

void test_descriptor() {
  const auto* euclid = find_module("euclid");
  assert(euclid && euclid == &euclid_module_descriptor());
  assert(module_count() == 18 && module_at(8) == euclid && !find_module("phraser"));
  assert(euclid->version == 1 && euclid->param_count == 8);

  // euclid.py: LANE=0 (0..5), RATE=8, PULSES=4 (0..128), LENGTH=16 (1..128), ROT=0 (-127..127),
  // SORT=UP (UP/DOWN/ORD), GATE=100 (0..100000, step 5), RTRG=STBL (STBL/CONT/RTRG).
  const char* names[] = {"lane", "rate", "pulses", "length", "rotation", "sort", "gate", "retrigger_mode"};
  const std::int32_t defaults[] = {0, 8, 4, 16, 0, 0};
  const std::int32_t minimums[] = {0, 0, 0, 1, -127, 0};
  const std::int32_t maximums[] = {5, 12, 128, 128, 127, 2};
  for (std::uint8_t i = 0; i < 8; ++i) {
    const ParamSpec& p = euclid->params[i];
    assert(std::strcmp(p.name, names[i]) == 0);
    assert(p.flags & ParamPersist);
    if (i == 6) {
      assert(p.type == ParamType::Decimal && p.default_value.value.decimal == 100.0f);
      assert(p.minimum.value.decimal == 0.0f && p.maximum.value.decimal == 100000.0f);
      assert(p.step.value.decimal == 5.0f);
      continue;
    }
    if (i == 7) {
      assert(p.default_value.value.integer == 0 && p.maximum.value.integer == 2);
      continue;
    }
    if (i == 5) {
      assert(p.option_count == 3 && std::strcmp(p.options[0], "UP") == 0 && std::strcmp(p.options[2], "ORD") == 0);
    }
    assert(p.default_value.value.integer == defaults[i]);
    assert(p.minimum.value.integer == minimums[i] && p.maximum.value.integer == maximums[i]);
  }
  assert(std::strcmp(euclid->params[7].options[0], "STBL") == 0 && std::strcmp(euclid->params[7].options[2], "RTRG") == 0);
  assert(euclid->params[5].step.value.integer == 1 && euclid->params[2].step.value.integer == 1);
}

void test_attributes() {
  const auto* euclid = find_module("euclid");
  Run r(*euclid);
  Collect c;
  AttributeVisitor visitor{&c, collect};
  euclid->attributes(r.state, visitor);
  assert(c.count == 3);
  assert(std::strcmp(c.names[0], "pulses") == 0 && std::strcmp(c.names[1], "lengths") == 0 &&
         std::strcmp(c.names[2], "rotations") == 0);
  assert(c.elements[0] == 6 && c.elements[1] == 6 && c.elements[2] == 6);
  assert(c.types[0] == AttributeType::Byte && c.types[1] == AttributeType::Byte && c.types[2] == AttributeType::Integer);
  // 18 saved values in total, matching save_attrs = ("pulses", "lengths", "rotations").
  assert(c.elements[0] + c.elements[1] + c.elements[2] == 18);
  assert(c.values[0] == r.state.storage.euclid.pulses && c.values[1] == r.state.storage.euclid.lengths &&
         c.values[2] == r.state.storage.euclid.rotations);

  // The defaults match the source constructor: pulses 4, lengths 16, rotations 0.
  for (std::size_t lane = 0; lane < kEuclidLanes; ++lane) {
    assert(r.state.storage.euclid.pulses[lane] == 4 && r.state.storage.euclid.lengths[lane] == 16);
    assert(r.state.storage.euclid.rotations[lane] == 0);
  }
}

void test_step_tables() {
  // Bitmask rows (steps 1..32): bit s set exactly when euclid_step(s, pulses, steps) holds.
  for (const auto& row : kEuclidStepTable) {
    for (std::uint32_t s = 0; s < row.steps; ++s) {
      const bool expected = ((row.mask >> s) & 1U) != 0;
      assert(euclid_step(s, row.pulses, row.steps) == expected);
    }
  }
  // Long lengths: the source hit count equals pulses (Euclidean distribution).
  for (const auto& row : kEuclidCountTable) {
    std::uint32_t hits = 0;
    for (std::uint32_t s = 0; s < row.steps; ++s) hits += euclid_step(s, row.pulses, row.steps) ? 1U : 0U;
    assert(hits == row.hits && hits == row.pulses);
  }
  // Edge cases from the source guard: no steps or no pulses is silent; full pulses always hit.
  assert(!euclid_step(0, 0, 8) && !euclid_step(0, 3, 0));
  assert(euclid_step(5, 8, 8) && euclid_step(0, 9, 8));
  // Two of eight, from the source formula: hits at steps 2 and 5 (and 7 for three of eight).
  assert(euclid_step(2, 3, 8) && euclid_step(5, 3, 8) && euclid_step(7, 3, 8) && !euclid_step(3, 3, 8));
}

void test_parameter_bounds() {
  Run r(euclid_module_descriptor());
  const auto& d = euclid_module_descriptor();
  std::uint8_t effects = 0;
  const GlobalState global{};
  // Rejections: out-of-range ints, out-of-range enums, wrong type, out-of-range gate.
  assert(!d.set_param(r.state, 0, ParamValue::integer(6), global, effects));
  assert(!d.set_param(r.state, 0, ParamValue::integer(-1), global, effects));
  assert(!d.set_param(r.state, 1, ParamValue::integer(13), global, effects));
  assert(!d.set_param(r.state, 2, ParamValue::integer(129), global, effects));
  assert(!d.set_param(r.state, 3, ParamValue::integer(0), global, effects));
  assert(!d.set_param(r.state, 4, ParamValue::integer(128), global, effects));
  assert(!d.set_param(r.state, 4, ParamValue::integer(-128), global, effects));
  assert(!d.set_param(r.state, 5, ParamValue::integer(3), global, effects));
  assert(!d.set_param(r.state, 6, ParamValue::decimal(-0.5f), global, effects));
  assert(!d.set_param(r.state, 6, ParamValue::decimal(100000.5f), global, effects));
  assert(!d.set_param(r.state, 6, ParamValue::integer(100), global, effects));
  assert(!d.set_param(r.state, 7, ParamValue::integer(3), global, effects));
  assert(!d.set_param(r.state, 8, ParamValue::integer(0), global, effects));
  // Boundary values are accepted.
  assert(d.set_param(r.state, 0, ParamValue::integer(5), global, effects) && effects == EffectRepaint);
  assert(d.set_param(r.state, 3, ParamValue::integer(128), global, effects) && effects == EffectNone);
  assert(d.set_param(r.state, 4, ParamValue::integer(-127), global, effects));
  assert(d.set_param(r.state, 6, ParamValue::decimal(100000.0f), global, effects));
  assert(d.set_param(r.state, 7, ParamValue::integer(2), global, effects));
  assert(r.state.storage.euclid.lane == 5 && r.state.storage.euclid.lengths[5] == 128);
  assert(r.state.storage.euclid.rotations[5] == -127 && r.state.storage.euclid.gate == 100000.0f);
  assert(r.state.storage.euclid.retrigger_mode == 2);
}

// LENGTH shrinks PULSES of the selected lane only (source set_length). Other lanes are untouched.
void test_length_clamps_pulses() {
  const auto& d = euclid_module_descriptor();
  Run r(d);
  std::uint8_t effects = 0;
  const GlobalState global{};
  auto& s = r.state.storage.euclid;
  assert(d.set_param(r.state, 0, ParamValue::integer(2), global, effects));
  assert(d.set_param(r.state, 2, ParamValue::integer(20), global, effects));
  assert(d.set_param(r.state, 3, ParamValue::integer(7), global, effects) && effects == EffectRepaint);
  assert(s.pulses[2] == 7 && s.lengths[2] == 7);
  assert(s.pulses[0] == 4 && s.lengths[0] == 16);
  // A length above the current pulses leaves pulses alone.
  assert(d.set_param(r.state, 3, ParamValue::integer(30), global, effects) && effects == EffectNone);
  assert(s.pulses[2] == 7 && s.lengths[2] == 30);
}

// A zero length can only arrive through an unvalidated attribute restore. It must not crash
// (deviation 1); lane 0 is silent and other lanes behave normally.
void test_zero_length_guard() {
  const auto& d = euclid_module_descriptor();
  Run r(d);
  const GlobalState global{};
  std::uint8_t effects = 0;
  assert(d.set_param(r.state, 2, ParamValue::integer(1), global, effects));  // lane 0 pulses = 1
  AttributeVisitor visitor{nullptr, zero_length_lane0};
  d.attributes(r.state, visitor);
  assert(r.state.storage.euclid.lengths[0] == 0);
  // Lane 0 is silent (no hit ever), and the other lanes have no pattern hit on these steps.
  r.step(0, 0, true, {{60, 100}}, {}, {}, {});
  r.step(10, 6, true, {}, {}, {}, {});
  r.step(20, 12, true, {}, {}, {}, {});
  assert(r.state.storage.euclid.active_pitch[0] == 255);
}

// The 13th distinct held note is dropped as in the source (its on never sounds), counted in
// held_overflow. The pitch can be pressed again once an older held note is released.
void test_held_capacity() {
  Run r(euclid_module_descriptor());
  for (std::uint8_t i = 0; i < kPolyphony; ++i) {
    NoteBatch out = r.process(0, 0, true, {{static_cast<std::uint8_t>(48 + i), 100}}, {});
    (void)out;
  }
  assert(r.state.storage.euclid.held.count == kPolyphony && r.state.storage.euclid.held_overflow == 0);
  (void)r.process(1, 0, true, {{72, 100}}, {});
  assert(r.state.storage.euclid.held.count == kPolyphony && r.state.storage.euclid.held_overflow == 1);
  // The dropped note's release matches nothing and is silent.
  r.step(2, 0, true, {}, {72}, {}, {});
  assert(r.state.storage.euclid.held_overflow == 1);
}

// Stop clears held notes and lane voices without output (the chain's all-notes-off releases
// anything sounding). After a stop, the next transport start restarts the CONT/RTRG counter.
void test_stop_clears_state() {
  Run r(euclid_module_descriptor());
  r.set_int(7, 2);
  // RTRG restarts at the note-on; lane 0 (4 of 16) has no hit at step 0.
  r.step(0, 0, true, {{60, 100}}, {}, {}, {});
  r.stop();
  assert(r.state.storage.euclid.held.count == 0 && r.state.storage.euclid.note_order.count == 0);
  assert(r.state.storage.euclid.active_pitch[0] == 255 && r.state.storage.euclid.last_grid_bin == -1);
  assert(!r.state.storage.euclid.was_running && r.state.storage.euclid.step_index == 0);
  r.step(10, 6, true, {}, {}, {}, {});
}

// Random play with note-ons, releases, transport starts and stops. Invariants: every off matches
// a sounding note (no duplicate release), output lists stay within six lanes, and after all
// held notes are released and the transport stops, nothing is left sounding.
void test_no_stuck_notes() {
  std::uint32_t seed = 0x9E3779B9U;
  auto next = [&seed]() {
    seed = seed * 1664525U + 1013904223U;
    return seed >> 8;
  };
  for (int round = 0; round < 48; ++round) {
    Run r(euclid_module_descriptor());
    const auto& d = euclid_module_descriptor();
    std::uint8_t effects = 0;
    for (std::uint8_t lane = 0; lane < kEuclidLanes; ++lane) {
      assert(d.set_param(r.state, 0, ParamValue::integer(lane), r.global, effects));
      assert(d.set_param(r.state, 3, ParamValue::integer(static_cast<std::int32_t>(1 + next() % 16)), r.global, effects));
      assert(d.set_param(r.state, 2, ParamValue::integer(static_cast<std::int32_t>(next() % 17)), r.global, effects));
      assert(d.set_param(r.state, 4, ParamValue::integer(static_cast<std::int32_t>(next() % 255) - 127), r.global, effects));
    }
    assert(d.set_param(r.state, 0, ParamValue::integer(0), r.global, effects));
    r.set_int(5, static_cast<std::int32_t>(next() % 3));
    r.set_int(7, static_cast<std::int32_t>(next() % 3));
    r.set_float(6, static_cast<float>(next() % 400));

    std::int32_t sounding[128] = {};
    bool held[128] = {};
    std::uint32_t now = 0;
    std::uint32_t tick = 0;
    for (int stepno = 0; stepno < 300; ++stepno) {
      Pair ons[2]{};
      std::uint8_t on_count = 0;
      if (next() % 3 == 0) {
        const auto pitch = static_cast<std::uint8_t>(48 + next() % 24);
        ons[on_count++] = {pitch, static_cast<std::uint8_t>(1 + next() % 127)};
        held[pitch] = true;
      }
      std::uint8_t offs[2]{};
      std::uint8_t off_count = 0;
      if (next() % 4 == 0) {
        const auto pitch = static_cast<std::uint8_t>(48 + next() % 24);
        if (held[pitch]) {
          offs[off_count++] = pitch;
          held[pitch] = false;
        }
      }
      const bool running = next() % 8 != 0;
      tick += next() % 7;
      now += 1 + next() % 30;
      NoteBatch input{};
      for (std::uint8_t i = 0; i < on_count; ++i) assert(input.on.append({ons[i].pitch, ons[i].velocity, 0}) == PushResult::Added);
      for (std::uint8_t i = 0; i < off_count; ++i) assert(input.off.append({offs[i], 0, 0}) == PushResult::Added);
      TransportView view{};
      view.running = running;
      view.tick = tick;
      ProcessContext context{TimeSample{now, 0}, r.global, view, r.random};
      NoteBatch output{};
      d.process(r.state, context, input, output);
      assert(!output.overflowed() && output.on.count <= kEuclidLanes && output.off.count <= kEuclidLanes);
      for (std::uint16_t i = 0; i < output.off.count; ++i) {
        const auto pitch = output.off.items[i].pitch;
        assert(sounding[pitch] > 0);
        --sounding[pitch];
      }
      for (std::uint16_t i = 0; i < output.on.count; ++i) ++sounding[output.on.items[i].pitch];
    }
    // Release every held note, then stop the transport: all sounding notes must be released.
    // Offs go out in batches of at most kPolyphony (the test's own input capacity).
    std::uint8_t next_pitch = 0;
    do {
      NoteBatch input{};
      while (next_pitch < 128 && input.off.count < kPolyphony) {
        if (held[next_pitch]) {
          assert(input.off.append({next_pitch, 0, 0}) == PushResult::Added);
          held[next_pitch] = false;
        }
        ++next_pitch;
      }
      TransportView view{};
      view.running = false;
      ProcessContext context{TimeSample{now + 1, 0}, r.global, view, r.random};
      NoteBatch output{};
      d.process(r.state, context, input, output);
      for (std::uint16_t i = 0; i < output.off.count; ++i) {
        assert(sounding[output.off.items[i].pitch] > 0);
        --sounding[output.off.items[i].pitch];
      }
    } while (next_pitch < 128);
    for (int pitch = 0; pitch < 128; ++pitch) assert(sounding[pitch] == 0);
  }
}

}  // namespace

int main() {
  test_descriptor();
  test_attributes();
  test_step_tables();
  test_parameter_bounds();
  test_length_clamps_pulses();
  test_zero_length_guard();
  test_held_capacity();
  test_stop_clears_state();
  test_no_stuck_notes();

  {
    Run r(euclid_module_descriptor());
    trace_defaults_three_notes(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_lane_patterns(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_gate_30(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_gate_zero(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_gate_fractional(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_gate_change_running(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_length_clamps_pulses(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_rtrg_restart(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_cont_repeated_passes(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_stbl_jump_backwards(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_reassign_multiplicity(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_double_release(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_sort_down(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_sort_ord(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_held_capacity(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_stop_reset(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_transport_stopped_release(r);
  }
  {
    Run r(euclid_module_descriptor());
    trace_wrap_gate(r);
  }
  return 0;
}
